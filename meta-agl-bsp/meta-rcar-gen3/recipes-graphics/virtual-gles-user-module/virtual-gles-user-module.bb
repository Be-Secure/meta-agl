DESCRIPTION = "Virtual gles-module"

LICENSE="GPLv2"

DEPENDS = "gles-user-module wayland-kms libgbm wayland-wsegl"

PROVIDES = "virtual/libgles2 virtual/egl"
